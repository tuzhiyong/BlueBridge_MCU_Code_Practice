# Keil uVision project 练习-第十一届省赛题（第二次）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 练习-第十一届省赛题（第二次） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c stc15.h onewire.c onewire.h iic.c iic.h PCF8591.c PCF8591.h
