# Keil uVision project 练习-第十届省赛题.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 练习-第十届省赛题 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: stc15.h main.c PCF8591.c PCF8591.h iic.c iic.h
