# Keil uVision project 练习-第10届国赛题.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 练习-第10届国赛题 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: stc15.h main.c onewire.c onewire.h iic.c iic.h PCF8591.c PCF8591.h AT24C02.h AT24C02.c
