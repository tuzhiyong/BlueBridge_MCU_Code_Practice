# Keil uVision project 练习-第十二届省赛题（第一次）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 练习-第十二届省赛题（第一次） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c stc15.h iic.c onewire.c iic.h onewire.h PCF8591.h pcf8591.c DS18B20.c DS18B20.h
