# Keil uVision project 练习-第13届省赛题（第1次）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 练习-第13届省赛题（第1次） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.h main.c stc15.h onewire.h onewire.c ds1302.h ds1302.c
