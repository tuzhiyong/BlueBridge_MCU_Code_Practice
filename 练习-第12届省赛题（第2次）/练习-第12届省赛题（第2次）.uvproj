# Keil uVision project 练习-第12届省赛题（第2次）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 练习-第12届省赛题（第2次） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: iic.c iic.h main.c PCF8591.c PCF8591.h stc15.h
