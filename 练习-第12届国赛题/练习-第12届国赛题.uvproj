# Keil uVision project 练习-第12届国赛题.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 练习-第12届国赛题 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main.h stc15.h ds1302.c ds1302.h iic.c iic.h PCF8591.c PCF8591.h
