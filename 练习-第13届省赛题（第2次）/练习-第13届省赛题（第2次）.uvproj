# Keil uVision project 练习-第13届省赛题（第2次）.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 练习-第13届省赛题（第2次） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c stc15.h main.h PCF8591.h PCF8591.c iic.c iic.h
